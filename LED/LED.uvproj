# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51
  group Source Group 1
    ./: STARTUP.A51 main.c
