# Keil uVision project UartAndLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: UartAndLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group Source Group 1
    ./: STARTUP.A51 main.c
  group lib
    ../lib/: mykey.c mykey.h myled.c myled.h mylib.c mylib.h mytimer.c mytimer.h mytube.c mytube.h myuart.c myuart.h
